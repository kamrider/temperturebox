# Keil uVision project temperature_control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ds18b20;..\SYSTEM\dwt_delay;..\SYSTEM\SysTick;..\SYSTEM\General Time;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\PID;..\SYSTEM\timer;..\SYSTEM\General Time;..\SYSTEM\PID;..\SYSTEM\usart;..\HARDWARE\OLED2;..\HARDWARE\air780;..\HARDWARE\menu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ./: LED.c
    ../HARDWARE/ds18b20/: bsp_ds18b20.c
    ../HARDWARE/Key/: bsp_key.c
    ../HARDWARE/OLED2/: OLED2.c
    ../HARDWARE/air780/: bsp_air780.c
    ../HARDWARE/menu/: bsp_menu.c
  group SYSTEM
    ../SYSTEM/General Time/: bsp_GeneralTim.c
    ../SYSTEM/PID/: pid.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/usart/: bsp_usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/dwt_delay/: core_delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
